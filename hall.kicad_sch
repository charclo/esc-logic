File: hall.kicad_sch (KiCad schematic)
At the start: 5 parts

Commit message: what changed?
Parts:
- C45: LCSC (none) -> C49678
- R24: LCSC (none) -> C84376
