File: CAN.kicad_sch (KiCad schematic)
At the start: 4 parts, among them U6 TJA1051T-3

Commit message: what changed?
Parts:
- C25, C6: LCSC (none) -> C319190
- R14: LCSC C422823 -> C114245
